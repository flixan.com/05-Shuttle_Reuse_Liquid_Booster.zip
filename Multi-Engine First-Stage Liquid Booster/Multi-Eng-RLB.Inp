BATCH MODE INSTRUCTIONS ...............                                                             
Batch for calculating the open and closed loop models for a multi-engine launch vehicle
! This batch set creates a state-space model for a Shuttle type vehicle that uses a first 
! stage liquid booster with mutiple engines some of which have variable thrust capability. 
! It creates a mixing logic matrix that combines the engine gimbaling and throttling in 
! response to roll, pitch and yaw flight control acceleration demands. The batch also creates 
! simple actuator models for the engine gimbaling and throttling, and the combined pitch and 
! lateral flight control system at Max-Q. It combines also the vehicle model with the actuators 
! and the flight control system in open-loop form to create a frequency domain analysis model and 
! also in closed-loop form for simulations. The combined systems are converted to Matlab format.
!
Flight Vehicle   : Throttable Multi-Engine Launch Vehicle at Max-Q, T=72 sec                
Mixing Matrix    : Mixing Logic for the Multi-Engine Throttable Booster [ThVC: PQR-dot] 
Transf-Function  : Actuator 2nd Order 
Transf-Function  : Throttle Actuators 
System Connection: Combined Actuator  
System Connection: TVC and Throttle Control Actuators Combined  
Transf-Function  : Ascent Pitch FCS, High Q_bar 
Transf-Function  : Lateral FCS for High Q_bar 
System Connection: Combined Flight Control System (Roll, Pitch, Yaw)
System Connection: Open-Loop System
System Connection: Closed-Loop Simulation
To Matlab Format : Mixing Logic for the Multi-Engine Throttable Booster [ThVC: PQR-dot]
To Matlab Format : Throttable Multi-Engine Launch Vehicle at Max-Q, T=72 sec
To Matlab Format : Combined Actuator
To Matlab Format : Combined Flight Control System (Roll, Pitch, Yaw)
To Matlab Format : Open-Loop System
To Matlab Format : Closed-Loop Simulation
----------------------------------------------------------------------------------------------------------------------------
FLIGHT VEHICLE INPUT DATA ......
Throttable Multi-Engine Launch Vehicle at Max-Q, T=72 sec
! This is a first stage Shuttle type Launch Vehicle with 9 Engines. The first 3 are Shuttle 
! Main Engines gimbaling in Pitch and Yaw. The remaining 6 are liquid engines mounted on a
! first stage booster that separates at the end of first stage. The booster engines gimbal 4
! (deg) in pitch and 1.2 (deg) in yaw. The booster engines are also able to vary their thrust
! from a nominal value 0.96 million pounds to +/- 45% each. The slosh frequencies are at 1 g
!
Body Axes Output,Attitude=Euler Angles,Without GAFD, No Turn Coordination  
  
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :  0.109755E+6  32.099        0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  0.4491E+8    0.265151E+9   0.293892E+9  0.0  0.5293E+7  0.0   
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        : -126.004      0.01956      -35.2971
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.800        1486.69       684.10       37814.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  57.068       57.068        0.045        11.9895
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         : -4.35        -0.0371        0.0000       0.0000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :  0.00         53.942        0.0000       0.0          0.1729       0.0
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:  Gust         45.0          53.942    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :  2690.0       39.56         78.05     
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} : -126.004      0.0          -35.2971      0.0000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.47492      0.000         0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:  0.00205     -0.056068      0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}:  0.449856    -0.108216      0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:  0.0012078   -0.005449568   0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.137575    -0.0197738     0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}: -0.0012913    0.016880321   0.0000       0.0000       0.0000       0.0000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  0   NO TWD  

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  9   WITH TWD  

TVC Engine No:  1                                (Gimbaling  Throttling   Single_Gimbal) : SSME Top-Cent   Gimbaling only
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  471480.0      471480.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -16.47         0.0          10.0         10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0         4032.0       3.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -182.16        0.0         -64.94    
TVC Engine No:  2                                (Gimbaling  Throttling   Single_Gimbal) : SSME Left       Gimbaling only
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  471480.0      471480.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.8          3.5          10.0         10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0         4032.0       3.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1        -4.4         -56.33   
TVC Engine No:  3                                (Gimbaling  Throttling   Single_Gimbal) : SSME Right      Gimbaling only
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  471480.0      471480.0  
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -10.8         -3.5          10.0         10.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  210.0         4032.0       3.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -184.1        +4.4         -56.33    
TVC Engine No:  4                                (Gimbaling  Throttling   Single_Gimbal) : LB Left-Top      Gimbaling  Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.96097e+6     1.4e+6 
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -1.2968         0.0         5.0          1.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  640.4          0.3454e+5   5.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -188.6         -24.41      -34.49    
TVC Engine No:  5                                (Gimbaling  Throttling   Single_Gimbal) : LB Right-Top     Gimbaling  Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.96097e+6     1.4e+6 
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -1.102          0.0         5.0          1.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  640.4          0.3454e+5   5.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -188.6          24.41      -34.49    
TVC Engine No:  6                                (Gimbaling  Throttling   Single_Gimbal) : LB Left-Left     Gimbaling  Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.96097e+6     1.4e+6 
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -1.2968         0.0         5.0          1.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  640.4          0.3454e+5   5.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -188.6         -31.91      -21.5    
TVC Engine No:  7                                (Gimbaling  Throttling   Single_Gimbal) : LB Left-Right    Gimbaling  Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.96097e+6     1.4e+6 
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -1.2968         0.0         5.0          1.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  640.4          0.3454e+5   5.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -188.6         -16.92      -21.5    
TVC Engine No:  8                                (Gimbaling  Throttling   Single_Gimbal) : LB Right-Left    Gimbaling  Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.96097e+6     1.4e+6 
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -1.102          0.0         5.0          1.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  640.4          0.3454e+5   5.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -188.6          16.92      -21.5    
TVC Engine No:  9                                (Gimbaling  Throttling   Single_Gimbal) : LB Right-Right   Gimbaling  Throttling
Engine Nominal Thrust, and Maximum Thrust in (lb)   (for throttling)                     :  0.96097e+6     1.4e+6 
Mounting Angles wrt Vehicle (Dyn,Dzn), Maximum Deflections from Mount (Dymax,Dzmax) (deg): -1.102          0.0         5.0          1.0   
Eng Mass (slug), Inertia about Gimbal (lb-sec^2-ft), Moment Arm, engine CG to gimbal (ft):  640.4          0.3454e+5   5.0  
Gimbal location with respect to the Vehicle Reference Axes, Xgimb, Ygimb, Zgimb, in (ft) : -188.6          31.91      -21.5    

Number of Gyros, (Attitude and Rate)                                                     :  0

Number of Accelerometers, Along Axis: (x,y,z)                                            :  2
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Z-axis Accelerat.    -93.62   0.0   -61.53             
Acceleromet No  1 Axis:(X,Y,Z), (Position, Velocity, Acceleration), Sensor Location (ft) :  Y-axis Accelerat.    -93.62   0.0   -61.53             

Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  0

Number of Slosh Modes                                                                    :  6
ET LOX Sl.Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  3064.0   2.3    2.3    0.0022  0.0022  -67.00   0.0   -33.0  
ET LH2 Sl.Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  512.0    2.05   2.05   0.0018  0.0018  -123.0   0.0   -33.0  
LB LOX Sl.Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  1100.0   2.55   2.55   0.005   0.005   -76.00  -24.5  -26.0  
LB LH2 Sl.Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  250.0    2.45   2.45   0.002   0.002   -142.0  -24.5  -26.0  
LB LOX Sl.Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  1100.0   2.55   2.55   0.005   0.005   -76.00  +24.5  -26.0  
LB LH2 Sl.Mass (slug), Frequ Wy,Wz 1g (rad/s), Damp (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft) :  250.0    2.45   2.45   0.002   0.002   -142.0  +24.5  -26.0  

Number of Bending Modes                                                                  :  0
                                                                                                    
----------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA .........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for the Multi-Engine Throttable Booster [ThVC: PQR-dot]             
! Mixing Logic Matrix for a Launch Vehicle at Max_Q. This mixing logic converts the Roll, 
! Pitch, and Yaw angular acceleration demands to gimbal deflections and thrust variations
! for the 3 Shuttle and the 6 Liquid Booster Engines. 
ThVC
Throttable Multi-Engine Launch Vehicle at Max-Q, T=72 sec
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
----------------------------------------------------------------------------------------------------------------------------
MIXING LOGIC MATRIX DATA .........    (Matrix Title, Name, Vehicle Title, Control Directions)
Mixing Logic for the Throttable Booster [Kmix23: PQR-dot plus Ax]                   
! Mixing Logic Matrix for a Launch Vehicle at Max_Q. This mixing logic converts the Roll, 
! Pitch, Yaw angular acceleration plus axial acceleration Ax demands to gimbal deflections 
! and thrust variations for the 3 Shuttle and the 6 Liquid Booster Engines. 
Kmix2
Throttable Multi-Engine Launch Vehicle at Max-Q, T=72 sec
P-dot Roll  Acceleration About X Axis                                           
Q-dot Pitch Acceleration About Y Axis                                           
R-dot Yaw   Acceleration About Z Axis                                           
Ax  Forward Acceleration Along X Axis                                           
------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Actuator 2nd Order
! A 20 (rad/sec) bandwidth TVC Gimbal Actuator
Continuous
TF. Block #  1 Integrator delta-dot                              Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.00000     0.00000  
TF. Block #  2 Integrator delta                                  Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.00000     0.00000  
-------------------------------------------------------------------------------
Block #, from Input #, Gain
  1  1    506.0
...........................
Block #, from Block #, Gain
  2  1    1.0
  1  1   -34.0
  1  2   -506.0
...........................
Outpt #, from Block #, Gain
  1  2    1.0
  2  1   -34.0
  2  2   -506.0
...........................
Outpt #, from Input #, Gain
  2  1    506.0
...........................
Definitions of Inputs  =   1
Deflection Command (rad)                                                      
 
Definitions of Outputs =   2
Gimbal Deflection (rad)
Gimbal Acceleration (rad/sec^2)                                                             
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Throttle Actuators
! 8 (rad/sec) bandwidth Throttle Control Actuator
Continuous
TF. Block #  1 Engine-1                                          Order of Numer, Denom=  0  1
Numer 0.0         8.0
Denom 1.0         8.0
TF. Block #  2 Engine-2                                          Order of Numer, Denom=  0  1
Numer 0.0         8.0
Denom 1.0         8.0
TF. Block #  3 Engine-3                                          Order of Numer, Denom=  0  1
Numer 0.0         8.0
Denom 1.0         8.0
TF. Block #  4 Engine-4                                          Order of Numer, Denom=  0  1
Numer 0.0         8.0
Denom 1.0         8.0
TF. Block #  5 Engine-5                                          Order of Numer, Denom=  0  1
Numer 0.0         8.0
Denom 1.0         8.0
TF. Block #  6 Engine-6                                          Order of Numer, Denom=  0  1
Numer 0.0         8.0
Denom 1.0         8.0
-------------------------------------------------------------------------------
Block #, from Input #, Gain
  1  1    1.0
  2  2    1.0
  3  3    1.0
  4  4    1.0
  5  5    1.0
  6  6    1.0
...........................
Outpt #, from Block #, Gain
  1  1    1.0
  2  2    1.0
  3  3    1.0
  4  4    1.0
  5  5    1.0
  6  6    1.0
...........................
Definitions of Inputs  =   6
Engine 1 Throttle Input       
Engine 2 Throttle Input       
Engine 3 Throttle Input       
Engine 4 Throttle Input       
Engine 5 Throttle Input       
Engine 6 Throttle Input       
 
Definitions of Outputs =   6
Engine 1 Throttle Output       
Engine 2 Throttle Output       
Engine 3 Throttle Output       
Engine 4 Throttle Output       
Engine 5 Throttle Output       
Engine 6 Throttle Output       
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Combined Actuator                                                                                          
! Combine in parallel all the 2nd Order actuators for the nine engines   
Titles of Systems to be Combined
Title 1 Actuator 2nd Order
Title 2 Actuator 2nd Order
Title 3 Actuator 2nd Order
Title 4 Actuator 2nd Order
Title 5 Actuator 2nd Order
Title 6 Actuator 2nd Order
Title 7 Actuator 2nd Order
Title 8 Actuator 2nd Order
Title 9 Actuator 2nd Order
SYSTEM INPUTS TO SUBSYSTEM  1                                         Engine # 1                     
System Input  1 to Subsystem  1, Input  1, Gain=   1.0000             delta-1-comd                  
......................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                         Engine # 2                     
System Input  2 to Subsystem  2, Input  1, Gain=   1.0000             delta-2-comd        
......................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                         Engine # 3                     
System Input  3 to Subsystem  3, Input  1, Gain=   1.0000             delta-3-comd                
......................................................................
SYSTEM INPUTS TO SUBSYSTEM  4                                         Engine # 4                     
System Input  4 to Subsystem  4, Input  1, Gain=   1.0000             delta-4-comd                  
......................................................................
SYSTEM INPUTS TO SUBSYSTEM  5                                         Engine # 5                     
System Input  5 to Subsystem  5, Input  1, Gain=   1.0000             delta-5-comd                  
......................................................................
SYSTEM INPUTS TO SUBSYSTEM  6                                         Engine # 6                     
System Input  6 to Subsystem  6, Input  1, Gain=   1.0000             delta-6-comd                  
......................................................................
SYSTEM INPUTS TO SUBSYSTEM  7                                         Engine # 7                     
System Input  7 to Subsystem  7, Input  1, Gain=   1.0000             delta-7-comd                  
......................................................................
SYSTEM INPUTS TO SUBSYSTEM  8                                         Engine # 8                     
System Input  8 to Subsystem  8, Input  1, Gain=   1.0000             delta-8-comd                  
......................................................................
SYSTEM INPUTS TO SUBSYSTEM  9                                         Engine # 9                     
System Input  9 to Subsystem  9, Input  1, Gain=   1.0000             delta-9-comd                  
......................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1
System Output  1 from Subsystem  1, Output  1, Gain= 1.0              delta-1-out
System Output 10 from Subsystem  1, Output  2, Gain= 1.0              delta-1-ddot
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2
System Output  2 from Subsystem  2, Output  1, Gain= 1.0              delta-2-out
System Output 11 from Subsystem  2, Output  2, Gain= 1.0              delta-2-ddot
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3
System Output  3 from Subsystem  3, Output  1, Gain= 1.0              delta-3-out
System Output 12 from Subsystem  3, Output  2, Gain= 1.0              delta-3-ddot
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  4
System Output  4 from Subsystem  4, Output  1, Gain= 1.0              delta-4-out
System Output 13 from Subsystem  4, Output  2, Gain= 1.0              delta-4-ddot
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  5
System Output  5 from Subsystem  5, Output  1, Gain= 1.0              delta-5-out
System Output 14 from Subsystem  5, Output  2, Gain= 1.0              delta-5-ddot
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  6
System Output  6 from Subsystem  6, Output  1, Gain= 1.0              delta-6-out
System Output 15 from Subsystem  6, Output  2, Gain= 1.0              delta-6-ddot
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  7
System Output  7 from Subsystem  7, Output  1, Gain= 1.0              delta-7-out
System Output 16 from Subsystem  7, Output  2, Gain= 1.0              delta-7-ddot
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  8
System Output  8 from Subsystem  8, Output  1, Gain= 1.0              delta-8-out
System Output 17 from Subsystem  8, Output  2, Gain= 1.0              delta-8-ddot
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  9
System Output  9 from Subsystem  9, Output  1, Gain= 1.0              delta-9-out
System Output 18 from Subsystem  9, Output  2, Gain= 1.0              delta-9-ddot
..............................................................................
Definitions of Inputs  =   9
Delta-1 Command (rad)                                                              
Delta-2 Command (rad)                                                              
Delta-3 Command (rad)                                                              
Delta-4 Command (rad)                                                              
Delta-5 Command (rad)                                                              
Delta-6 Command (rad)                                                              
Delta-7 Command (rad)                                                              
Delta-8 Command (rad)                                                              
Delta-9 Command (rad)                                                              
 
Definitions of Outputs =  18
Gimbal Deftection-1 (rad)                                                          
Gimbal Deftection-2 (rad)                                                          
Gimbal Deftection-3 (rad)                                                          
Gimbal Deftection-4 (rad)                                                          
Gimbal Deftection-5 (rad)                                                          
Gimbal Deftection-6 (rad)                                                          
Gimbal Deftection-7 (rad)                                                          
Gimbal Deftection-8 (rad)                                                          
Gimbal Deftection-9 (rad)                                                          
Gimbal Accelerat-1 (rad/sec)                                                          
Gimbal Accelerat-2 (rad/sec)                                                          
Gimbal Accelerat-3 (rad/sec)                                                          
Gimbal Accelerat-4 (rad/sec)                                                          
Gimbal Accelerat-5 (rad/sec)                                                          
Gimbal Accelerat-6 (rad/sec)                                                          
Gimbal Accelerat-7 (rad/sec)                                                          
Gimbal Accelerat-8 (rad/sec)                                                          
Gimbal Accelerat-9 (rad/sec)                                                          
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
TVC and Throttle Control Actuators Combined                                                                                       
! Combine the 9 pitch, 9 yaw TVC actuators with the 6 Throttle 
! Control Actuators
Titles of Systems to be Combined
Title 1 Combined Actuator
Title 2 Combined Actuator
Title 3 Throttle Actuators
SYSTEM INPUTS TO SUBSYSTEM  1                                         Pitch Actuators                     
System Input  1 to Subsystem  1, Input  1, Gain=   1.0000             delta_y1-comd                  
System Input  2 to Subsystem  1, Input  2, Gain=   1.0000             delta_y2-comd                  
System Input  3 to Subsystem  1, Input  3, Gain=   1.0000             delta_y3-comd                  
System Input  4 to Subsystem  1, Input  4, Gain=   1.0000             delta_y4-comd                  
System Input  5 to Subsystem  1, Input  5, Gain=   1.0000             delta_y5-comd                  
System Input  6 to Subsystem  1, Input  6, Gain=   1.0000             delta_y6-comd                  
System Input  7 to Subsystem  1, Input  7, Gain=   1.0000             delta_y7-comd                  
System Input  8 to Subsystem  1, Input  8, Gain=   1.0000             delta_y8-comd                  
System Input  9 to Subsystem  1, Input  9, Gain=   1.0000             delta_y9-comd                  
......................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                         Yaw Actuators                     
System Input 10 to Subsystem  2, Input  1, Gain=   1.0000             delta_z1-comd                  
System Input 11 to Subsystem  2, Input  2, Gain=   1.0000             delta_z2-comd                  
System Input 12 to Subsystem  2, Input  3, Gain=   1.0000             delta_z3-comd                  
System Input 13 to Subsystem  2, Input  4, Gain=   1.0000             delta_z4-comd                  
System Input 14 to Subsystem  2, Input  5, Gain=   1.0000             delta_z5-comd                  
System Input 15 to Subsystem  2, Input  6, Gain=   1.0000             delta_z6-comd                  
System Input 16 to Subsystem  2, Input  7, Gain=   1.0000             delta_z7-comd                  
System Input 17 to Subsystem  2, Input  8, Gain=   1.0000             delta_z8-comd                  
System Input 18 to Subsystem  2, Input  9, Gain=   1.0000             delta_z9-comd                  
......................................................................
SYSTEM INPUTS TO SUBSYSTEM  3                                         Throttle Actuators                     
System Input 19 to Subsystem  3, Input  1, Gain=   1.0000             Throttle-1-comd                  
System Input 20 to Subsystem  3, Input  2, Gain=   1.0000             Throttle-2-comd                  
System Input 21 to Subsystem  3, Input  3, Gain=   1.0000             Throttle-3-comd                  
System Input 22 to Subsystem  3, Input  4, Gain=   1.0000             Throttle-4-comd                  
System Input 23 to Subsystem  3, Input  5, Gain=   1.0000             Throttle-5-comd                  
System Input 24 to Subsystem  3, Input  6, Gain=   1.0000             Throttle-6-comd                  
......................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                      Pitch Actuators
System Output  1 from Subsystem  1, Output  1, Gain= 1.0              delta-y-1
System Output  2 from Subsystem  1, Output  2, Gain= 1.0              delta-y-2
System Output  3 from Subsystem  1, Output  3, Gain= 1.0              delta-y-3
System Output  4 from Subsystem  1, Output  4, Gain= 1.0              delta-y-4
System Output  5 from Subsystem  1, Output  5, Gain= 1.0              delta-y-5
System Output  6 from Subsystem  1, Output  6, Gain= 1.0              delta-y-6
System Output  7 from Subsystem  1, Output  7, Gain= 1.0              delta-y-7
System Output  8 from Subsystem  1, Output  8, Gain= 1.0              delta-y-8
System Output  9 from Subsystem  1, Output  9, Gain= 1.0              delta-y-9
System Output 10 from Subsystem  1, Output 10, Gain= 1.0              delta-y-1-ddot
System Output 11 from Subsystem  1, Output 11, Gain= 1.0              delta-y-2-ddot
System Output 12 from Subsystem  1, Output 12, Gain= 1.0              delta-y-3-ddot
System Output 13 from Subsystem  1, Output 13, Gain= 1.0              delta-y-4-ddot
System Output 14 from Subsystem  1, Output 14, Gain= 1.0              delta-y-5-ddot
System Output 15 from Subsystem  1, Output 15, Gain= 1.0              delta-y-6-ddot
System Output 16 from Subsystem  1, Output 16, Gain= 1.0              delta-y-7-ddot
System Output 17 from Subsystem  1, Output 17, Gain= 1.0              delta-y-8-ddot
System Output 18 from Subsystem  1, Output 18, Gain= 1.0              delta-y-9-ddot
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                      Yaw Actuators
System Output 19 from Subsystem  2, Output  1, Gain= 1.0              delta-z-1
System Output 20 from Subsystem  2, Output  2, Gain= 1.0              delta-z-2
System Output 21 from Subsystem  2, Output  3, Gain= 1.0              delta-z-3
System Output 22 from Subsystem  2, Output  4, Gain= 1.0              delta-z-4
System Output 23 from Subsystem  2, Output  5, Gain= 1.0              delta-z-5
System Output 24 from Subsystem  2, Output  6, Gain= 1.0              delta-z-6
System Output 25 from Subsystem  2, Output  7, Gain= 1.0              delta-z-7
System Output 26 from Subsystem  2, Output  8, Gain= 1.0              delta-z-8
System Output 27 from Subsystem  2, Output  9, Gain= 1.0              delta-z-9
System Output 28 from Subsystem  2, Output 10, Gain= 1.0              delta-z-1-ddot
System Output 29 from Subsystem  2, Output 11, Gain= 1.0              delta-z-2-ddot
System Output 30 from Subsystem  2, Output 12, Gain= 1.0              delta-z-3-ddot
System Output 31 from Subsystem  2, Output 13, Gain= 1.0              delta-z-4-ddot
System Output 32 from Subsystem  2, Output 14, Gain= 1.0              delta-z-5-ddot
System Output 33 from Subsystem  2, Output 15, Gain= 1.0              delta-z-6-ddot
System Output 34 from Subsystem  2, Output 16, Gain= 1.0              delta-z-7-ddot
System Output 35 from Subsystem  2, Output 17, Gain= 1.0              delta-z-8-ddot
System Output 36 from Subsystem  2, Output 18, Gain= 1.0              delta-z-9-ddot
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                      Throttle Actuators
System Output 37 from Subsystem  3, Output  1, Gain= 1.0              Throttle-1
System Output 38 from Subsystem  3, Output  2, Gain= 1.0              Throttle-2
System Output 39 from Subsystem  3, Output  3, Gain= 1.0              Throttle-3
System Output 40 from Subsystem  3, Output  4, Gain= 1.0              Throttle-4
System Output 41 from Subsystem  3, Output  5, Gain= 1.0              Throttle-5
System Output 42 from Subsystem  3, Output  6, Gain= 1.0              Throttle-6
..............................................................................
Definitions of Inputs  =  24
Engine-1 Pitch Command (rad)   
Engine-2 Pitch Command (rad)   
Engine-3 Pitch Command (rad)   
Engine-4 Pitch Command (rad)   
Engine-5 Pitch Command (rad)   
Engine-6 Pitch Command (rad)   
Engine-7 Pitch Command (rad)   
Engine-8 Pitch Command (rad)   
Engine-9 Pitch Command (rad)   
Engine-1 Yaw Command (rad)   
Engine-2 Yaw Command (rad)   
Engine-3 Yaw Command (rad)   
Engine-4 Yaw Command (rad)   
Engine-5 Yaw Command (rad)   
Engine-6 Yaw Command (rad)   
Engine-7 Yaw Command (rad)   
Engine-8 Yaw Command (rad)   
Engine-9 Yaw Command (rad)   
Engine-4 Throttle Command 
Engine-5 Throttle Command 
Engine-6 Throttle Command 
Engine-7 Throttle Command 
Engine-8 Throttle Command 
Engine-9 Throttle Command 
 
Definitions of Outputs =  42
Engine-1 Pitch Deflection (rad)   
Engine-2 Pitch Deflection (rad)   
Engine-3 Pitch Deflection (rad)   
Engine-4 Pitch Deflection (rad)   
Engine-5 Pitch Deflection (rad)   
Engine-6 Pitch Deflection (rad)   
Engine-7 Pitch Deflection (rad)   
Engine-8 Pitch Deflection (rad)   
Engine-9 Pitch Deflection (rad)   
Engine-1 Pitch Acceleration (rad/sec^2)   
Engine-2 Pitch Acceleration (rad/sec^2)   
Engine-3 Pitch Acceleration (rad/sec^2)   
Engine-4 Pitch Acceleration (rad/sec^2)   
Engine-5 Pitch Acceleration (rad/sec^2)   
Engine-6 Pitch Acceleration (rad/sec^2)   
Engine-7 Pitch Acceleration (rad/sec^2)   
Engine-8 Pitch Acceleration (rad/sec^2)   
Engine-9 Pitch Acceleration (rad/sec^2)   
Engine-1 Yaw Deflection (rad)   
Engine-2 Yaw Deflection (rad)   
Engine-3 Yaw Deflection (rad)   
Engine-4 Yaw Deflection (rad)   
Engine-5 Yaw Deflection (rad)   
Engine-6 Yaw Deflection (rad)   
Engine-7 Yaw Deflection (rad)   
Engine-8 Yaw Deflection (rad)   
Engine-9 Yaw Deflection (rad)   
Engine-1 Yaw Acceleration (rad/sec^2)   
Engine-2 Yaw Acceleration (rad/sec^2)   
Engine-3 Yaw Acceleration (rad/sec^2)   
Engine-4 Yaw Acceleration (rad/sec^2)   
Engine-5 Yaw Acceleration (rad/sec^2)   
Engine-6 Yaw Acceleration (rad/sec^2)   
Engine-7 Yaw Acceleration (rad/sec^2)   
Engine-8 Yaw Acceleration (rad/sec^2)   
Engine-9 Yaw Acceleration (rad/sec^2)   
Engine-4 Throttle Output 
Engine-5 Throttle Output 
Engine-6 Throttle Output 
Engine-7 Throttle Output 
Engine-8 Throttle Output 
Engine-9 Throttle Output 
----------------------------------------------------------------------------------------------------------------------------
                  FLIGHT CONTROL SYSTEM
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Ascent Pitch FCS, High Q_bar
Continuous
TF. Block #  1  MQHP                                             Order of Numer, Denom=  1  1
Numer 1.0         0.0
Denom 1.0         1.0
TF. Block #  2  MNZ_LAG                                          Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.0         1.0
TF. Block #  3  MRO                                              Order of Numer, Denom=  1  2
Numer 0.0        +2.793       91.2
Denom 1.0        +11.11       91.2
TF. Block #  4  Integrator                                       Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.0         0.0
--------------------------------------------------------------------------------
Block #, from Input #, Gain
  1  2   1.0                                                    q_srb
  3  2   1.0                                                    q_srb
  3  1   0.24                                                   KM_Theta
  4  1   0.00696                                                KM_Int
  2  3   1.0                                                    MN_Zlag
...........................
Block #, from Block #, Gain
  3  2   8.0                                                    KM_Nz
  3  4   1.0                                                    KM_Int
  3  1   0.091                                                  KM_QHP*KM_NZ
...........................
Outpt #, from Block #, Gain
  1  3   1.0                                                    MRO
...........................
Definitions of Inputs  =   3
Theta Error (rad)                                                      
Pitch Rate (rad/sec)                                                      
Normal Acceleration Nz (ft/sec^2)
 
Definitions of Outputs =   1
FCS Pitch Demand DQ_TVC
----------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Lateral FCS for High Q_bar
Continuous
TF. Block #  1  Integrator Yaw                                   Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.0         0.0
TF. Block #  2  NLLA (s)                                         Order of Numer, Denom=  1  1
Numer 1.52        1.67
Denom 1.0         1.67
TF. Block #  3  N_Roff (s)                                       Order of Numer, Denom=  2  2
Numer 0.158       3.284       306.25
Denom 1.0         17.5        306.25
TF. Block #  4  NPRHP (s)                                        Order of Numer, Denom=  1  1
Numer 1.0         0.0
Denom 1.0         1.0
TF. Block #  5  NNY-(A) (s)                                      Order of Numer, Denom=  2  2
Numer 0.349      +1.635       99.22
Denom 1.0        +11.753      99.22
TF. Block #  6  NNY-(B) (s)                                      Order of Numer, Denom=  2  2
Numer 0.1717      0.8048      48.81
Denom 1.0        +8.3145      48.81
TF. Block #  7  NY_LAG (s)                                       Order of Numer, Denom=  0  1
Numer 0.0         1.0
Denom 1.0         1.0
TF. Block #  8  LLLA (s)                                         Order of Numer, Denom=  1  1
Numer 1.7         2.3
Denom 1.0         2.3
TF. Block #  9  L_RO (s)                                         Order of Numer, Denom=  2  2
Numer 0.096       5.862       484.0
Denom 1.0         23.32       484.0
-------------------------------------------------------------------------------
Block #, from Input #, Gain
  1   1      0.3                                                 psi_err to Yaw Integrator
  2   1      0.3                                                 psi_err to N_LLA
  2   3      1.0                                                 r_srb   to N_LLA
  4   3      1.0                                                 r_srb   to N_Prhp
  4   4     -0.68                                                p_orb   to N_Prhp
  8   1     -0.95                                                psi_err to LLLA via KL_psi
  8   2      0.77                                                phi_err to LLLA via KL_phi
  8   4      1.00                                                p_orb   to LLLA
  7   5      1.00                                                Ny_ err to NY_Lag
...........................
Block #, from Block #, Gain:
  6   5       1.0                                                NNY-A  to NNY-B
  2   6       1.0                                                NNY-B  to N_LLA
  3   2       1.0                                                N_LLA  to N_Roff
  5   4       1.0                                                N_PRHP to NNY-A
  5   7      40.0                                                NY_Lag to NNY-A via KN_Ny  was: 55
  9   8       1.0                                                L_LLA  to L_RO
...........................
Outpt #, from Block #, Gain
  2   1      0.28e-03                                            Integrat to DR_TVC
  2   3      1.0                                                 N_Roff   to DR_TVC
  1   3      1.69                                                N_Roff   to DP_TVC
  1   9      1.0                                                 L_RO     to DP_TVC
...........................
Definitions of Inputs  =   5
Psi Error (rad)                                                      
Phi Error (rad)                                                      
Yaw Rate (rad/sec)                                                      
Roll Rate (rad/sec)                                                      
Lateral Acceleration Ny (ft/sec^2)
 
Definitions of Outputs =   2
FCS Roll Demand DP_TVC
FCS Yaw Demand DR_TVC
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Combined Flight Control System (Roll, Pitch, Yaw)
! Combined Pitch and Lateral Flight Control System for the Shuttle type of Vehicle at 
! Max-Q (first stage s-plane controller)
Titles of Systems to be Combined
Title 1 Ascent Pitch FCS, High Q_bar
Title 2 Lateral FCS for High Q_bar
SYSTEM INPUTS TO SUBSYSTEM  1                                         Pitch Controller
System Input  2 to Subsystem  1, Input  1, Gain= 1.00000              Pitch Attitude
System Input  5 to Subsystem  1, Input  2, Gain= 1.00000              Pitch Rate
System Input  7 to Subsystem  1, Input  3, Gain= 0.52e-3              z-d-dot
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                         Lateral Controller
System Input  1 to Subsystem  2, Input  2, Gain= 1.00000              Roll Attitude
System Input  3 to Subsystem  2, Input  1, Gain= 1.00000              Yaw  Attitude
System Input  4 to Subsystem  2, Input  4, Gain= 1.00000              Roll Rate
System Input  6 to Subsystem  2, Input  3, Gain= 1.00000              Yaw  Rate
System Input  8 to Subsystem  2, Input  5, Gain= 0.0001               y-d-dot
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                      from Pitch FCS
System Output  2 from Subsystem  1, Output  1, Gain= 1.00             DQ-TVC
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                      from Lateral FCS
System Output  1 from Subsystem  2, Output  1, Gain= 1.00             DP-TVC
System Output  3 from Subsystem  2, Output  2, Gain= 0.85             DR-TVC
..............................................................................
Definitions of Inputs  =   8
Roll Attitude Error (rad)                                                              
Pitch Attitude Error (rad)                                                              
Yaw Attitude Error (rad)
Roll Rate (rad/sec) 
Pitch Rate (rad/sec) 
Yaw Rate (rad/sec) 
Normal Accelerom (Nz) (ft/sec^2)
Lateral Accelerom (Ny) (ft/sec^2)
 
Definitions of Outputs =   3
Roll FCS Demand (DP_TVC)
Pitch FCS Demand (DQ_TVC)
Yaw FCS Demand (DR_TVC)
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Open-Loop System
! Combined Actuators, Vehicle, and Flight Control System
! in Open-Loop form for frequency response analysis
Titles of Systems to be Combined
Title 1 TVC and Throttle Control Actuators Combined
Title 2 Throttable Multi-Engine Launch Vehicle at Max-Q, T=72 sec
Title 3 Combined Flight Control System (Roll, Pitch, Yaw)
SYSTEM INPUTS TO SUBSYSTEM  1                                             Actuators
Via Matrix +ThVC
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                          from FCS
Via Matrix +I3
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                   Actuator to Vehicle          
Via Matrix +I42
......................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  3                                   Vehicle to FCS          
Subsystem  2, Output  1 to Subsystem  3, Input  1, Gain= 1.0              Phi
Subsystem  2, Output  3 to Subsystem  3, Input  2, Gain= 1.0              Theta
Subsystem  2, Output  5 to Subsystem  3, Input  3, Gain= 1.0              Psi
Subsystem  2, Output  2 to Subsystem  3, Input  4, Gain= 1.0              p
Subsystem  2, Output  4 to Subsystem  3, Input  5, Gain= 1.0              q
Subsystem  2, Output  6 to Subsystem  3, Input  6, Gain= 1.0              r
Subsystem  2, Output 12 to Subsystem  3, Input  7, Gain= 1.0              Nz
Subsystem  2, Output 13 to Subsystem  3, Input  8, Gain= 1.0              Ny
......................................................................
Definitions of Inputs  =   3
Roll FCS Command (DP_TVC)            
Pitch FCS Command (DQ_TVC)            
Yaw FCS Command (DR_TVC)            
 
Definitions of Outputs =   3
Roll FCS Demand (DP_TVC)
Pitch FCS Demand (DQ_TVC)
Yaw FCS Demand (DR_TVC)
----------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Closed-Loop Simulation
! Combined Actuators, Vehicle, and Flight Control System
! in Closed-Loop form for time-domain Simulation Analysis
Titles of Systems to be Combined
Title 1 TVC and Throttle Control Actuators Combined
Title 2 Throttable Multi-Engine Launch Vehicle at Max-Q, T=72 sec
Title 3 Combined Flight Control System (Roll, Pitch, Yaw)
SYSTEM INPUTS TO SUBSYSTEM  3                                             Attit-Commands
Via Matrix -I3                                                            (phi,theta,psi)-Comds
..............................................................................
SYSTEM INPUTS TO SUBSYSTEM  2                                             Gust
System Input  4 to Subsystem  2, Input 43, Gain= 1.0                      Gust Veloc
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                          from Vehicle
Via Matrix +I13
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                          from Actuator
System Output 14 from Subsystem  1, Output  1, Gain= 1.00                 Dy-1
System Output 15 from Subsystem  1, Output  2, Gain= 1.00                 Dy-2
System Output 16 from Subsystem  1, Output  3, Gain= 1.00                 Dy-3
System Output 17 from Subsystem  1, Output  4, Gain= 1.00                 Dy-4
System Output 18 from Subsystem  1, Output  5, Gain= 1.00                 Dy-5
System Output 19 from Subsystem  1, Output  6, Gain= 1.00                 Dy-6
System Output 20 from Subsystem  1, Output  7, Gain= 1.00                 Dy-7
System Output 21 from Subsystem  1, Output  8, Gain= 1.00                 Dy-8
System Output 22 from Subsystem  1, Output  9, Gain= 1.00                 Dy-9
System Output 23 from Subsystem  1, Output 19, Gain= 1.00                 Dz-1
System Output 24 from Subsystem  1, Output 20, Gain= 1.00                 Dz-2
System Output 25 from Subsystem  1, Output 21, Gain= 1.00                 Dz-3
System Output 26 from Subsystem  1, Output 22, Gain= 1.00                 Dz-4
System Output 27 from Subsystem  1, Output 23, Gain= 1.00                 Dz-5
System Output 28 from Subsystem  1, Output 24, Gain= 1.00                 Dz-6
System Output 29 from Subsystem  1, Output 25, Gain= 1.00                 Dz-7
System Output 30 from Subsystem  1, Output 26, Gain= 1.00                 Dz-8
System Output 31 from Subsystem  1, Output 27, Gain= 1.00                 Dz-9
System Output 32 from Subsystem  1, Output 37, Gain= 1.00                 DThro-1
System Output 33 from Subsystem  1, Output 38, Gain= 1.00                 DThro-2
System Output 34 from Subsystem  1, Output 39, Gain= 1.00                 DThro-3
System Output 35 from Subsystem  1, Output 40, Gain= 1.00                 DThro-4
System Output 36 from Subsystem  1, Output 41, Gain= 1.00                 DThro-5
System Output 37 from Subsystem  1, Output 42, Gain= 1.00                 DThro-6
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                   Actuator to Vehicle          
Via Matrix +I42
......................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  3                                   Vehicle to FCS          
Subsystem  2, Output  1 to Subsystem  3, Input  1, Gain= 1.0              Phi
Subsystem  2, Output  3 to Subsystem  3, Input  2, Gain= 1.0              Theta
Subsystem  2, Output  5 to Subsystem  3, Input  3, Gain= 1.0              Psi
Subsystem  2, Output  2 to Subsystem  3, Input  4, Gain= 1.0              p
Subsystem  2, Output  4 to Subsystem  3, Input  5, Gain= 1.0              q
Subsystem  2, Output  6 to Subsystem  3, Input  6, Gain= 1.0              r
Subsystem  2, Output 12 to Subsystem  3, Input  7, Gain= 1.0              Nz
Subsystem  2, Output 13 to Subsystem  3, Input  8, Gain= 1.0              Ny
......................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  1                                   Vehicle to Actuator       
Via Matrix -ThVC                                                          Mixing Logic Matrix
......................................................................
Definitions of Inputs  =   4
Roll Attitude Command (phi)          
Pitch Attitude Command (theta) 
Yaw Attitude Command (psi) 
Wind Gust Velocity (ft/sec)         
         
Definitions of Outputs =  37
Roll Attitude  (phi-body) (radians)                                                          
Roll Rate      (p-body)   (rad/sec)                                                          
Pitch Attitude (thet-bdy) (radians)                                                          
Pitch Rate     (q-body)   (rad/sec)                                                          
Yaw  Attitude  (psi-body) (radians)                                                          
Yaw  Rate      (r-body)   (rad/sec)                                                          
Angle of attack, alfa, (radians)                                                             
Angle of sideslip, beta, (radian)                                                            
Change in Altitude, delta-h, (feet)                                                          
Forward Acceleration  (V-dot)  (ft/sec)                                                      
Cross Range Velocity (Vcr) (ft/sec)                                                          
Accelerom #  1, (along Z), (ft/sec^2) Translat. Accelerat.                                   
Accelerom #  2, (along Y), (ft/sec^2) Translat. Accelerat.      
Engine-1 Pitch Deftect (rad)    
Engine-2 Pitch Deftect (rad)    
Engine-3 Pitch Deftect (rad)    
Engine-4 Pitch Deftect (rad)    
Engine-5 Pitch Deftect (rad)    
Engine-6 Pitch Deftect (rad)    
Engine-7 Pitch Deftect (rad)    
Engine-8 Pitch Deftect (rad)    
Engine-9 Pitch Deftect (rad)    
Engine-1 Yaw Deftect (rad)    
Engine-2 Yaw Deftect (rad)    
Engine-3 Yaw Deftect (rad)    
Engine-4 Yaw Deftect (rad)    
Engine-5 Yaw Deftect (rad)    
Engine-6 Yaw Deftect (rad)    
Engine-7 Yaw Deftect (rad)    
Engine-8 Yaw Deftect (rad)    
Engine-9 Yaw Deftect (rad)    
Engine-4 Throttle    
Engine-5 Throttle    
Engine-6 Throttle    
Engine-7 Throttle    
Engine-8 Throttle    
Engine-9 Throttle    
----------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Mixing Logic for the Multi-Engine Throttable Booster [ThVC: PQR-dot]      
Matrix ThVC
ThVC.mat
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Throttable Multi-Engine Launch Vehicle at Max-Q, T=72 sec
System
Vehicle
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Combined Actuator
System
comb_actuator
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Combined Flight Control System (Roll, Pitch, Yaw)
System
fcs
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Open-Loop System                                                                                    
System
Openloop
------------------------------------------------------------------------------------------------------------------------
CONVERT TO MATLAB FORMAT ........      (Title, System/Matrix, m-filename)
Closed-Loop Simulation                                                                              
System
Closedloop.m
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-